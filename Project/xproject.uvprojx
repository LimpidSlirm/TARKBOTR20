# Keil uVision project xproject.uvprojx, settings and files
target OpenCTR (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: competition +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,APP_KEY_TURN_TEST=1
  c include: ..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\CMSIS\Include;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM4F;..\Driver;..\Robot;..\Driver\ax_oled;..\Robot\app;..\Robot\control;..\Robot\platform;..\Robot\modules\light;..\Robot\modules\ramp;..\Robot\modules\turn;..\Robot\modules\key
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Robot
    ../Robot/app/: main.c ax_robot.c
    ../Robot/platform/: stm32f4xx_it.c system_stm32f4xx.c FreeRTOSConfig.h
    ../Robot/control/: ax_speed.c ax_kinematics.c ax_control.c ax_akm.c
    ../Robot/modules/light/: ax_light.c
    ../Robot/modules/ramp/: ax_ramp.c ax_motion_sequence.c ax_ramp.h
    ../Robot/modules/turn/: ax_turn.c turn_control.c ax_turn.h turn_control.h
    ../Robot/modules/key/: key_module.c key_gpio_tarkbot.c key_module.h
  group Driver
    ../Driver/: ax_delay.c ax_led.c ax_sys.c ax_beep.c ax_switch.c ax_vin.c ax_key.c ax_uart1.c ax_uart2.c ax_uart3.c ax_uart4.c ax_mpu6050.c ax_motor.c ax_encoder.c ax_servo.c ax_rgb.c ax_can.c ax_eeprom.c ax_sbus.c ax_ps2.c ax_imu_bus.c ax_encoder_extended.c
    ../Driver/ax_oled/: ax_oled.c
  group Libraries
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group Doc
    ../Doc/: readme.txt
